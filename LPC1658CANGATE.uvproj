# Keil uVision project LPC1658CANGATE.uvproj, settings and files
target LPC1668 CANGATE (ARM-ADS)
  device: LPC1768 NXP
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(100000000) ELITTLE
  output: LPC1658CANGATE +hex
  c flags: Optim=1
  c include: .\source;.\driver\include;.\RTE\Device\LPC1768;.\driver\source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group source
    ./source/: main.c lpc17xx_pll_config.c
  group driver
    ./driver/source/: lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc17xx_uart.c lpc17xx_can.c debug_frmwrk.c
  group device
    ./RTE/Device/LPC1768/: core_cm3.c system_LPC17xx.c startup_LPC17xx.s
